# Keil uVision project GD32E503C_START.uvprojx, settings and files
target GD32E503C_START (6230000::V6.23::ARMCLANG)
  device: GD32E508VE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E508,USE_STDPERIPH_DRIVER
  c include: ..\.;..\..\..\..\GD32E50x_Firmware_Library\CMSIS;..\..\..\..\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\..\..\..\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --list=.\output\Project.map
  group Application
    ../: main.c bsp_usart.c bsp_half_duplex.c bsp_passband_tx.c bsp_passband_rx.c scfde_fft.c scfde_app.c scfde_equalizer.c scfde_modem.c scfde_ldpc.c gd32e50x_it.c systick.c main.h bsp_usart.h bsp_half_duplex.h bsp_passband_tx.h bsp_passband_rx.h scfde_fft.h scfde_app.h scfde_equalizer.h scfde_modem.h scfde_ldpc.h
  group CMSIS
    ../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
  group GD32E50x_Peripherals
    ../../../../GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c gd32e50x_can.c
  group GD32E50x_START
    ../../../Utilities/: gd32e503c_start.c
  group Startup
    ../../../../GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
  group Doc
    ../: README.md
software components: CMSIS:CORE 6.1.0
